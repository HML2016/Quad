# IAR project Flappy430v2Blu.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430F5310 MSP430F5310
  General.GStackSize2: 2048
  General.GHeapSize2: 1024
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: inc; src; $PROJ_DIR$
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F5310.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group inc
    inc/: Blue.h Dealy.h Debug_Out.h Delay.h FC.H Gpio_Init.h IIC_SENSOR.H MAG3110.H PWM.H Timer.h UCA1_UART1.H UCS_XTAL2.h
  group src
    src/: Blue.C Debug_Out.c Delay.c FC.C Gpio_Init.c IIC_SENSOR.C MAG3110.C main.c PWM.C Timer.c UCA1_UART1.C UCS_XTAL2.C
