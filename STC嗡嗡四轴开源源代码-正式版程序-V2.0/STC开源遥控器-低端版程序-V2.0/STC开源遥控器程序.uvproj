# Keil uVision project STC开源遥控器程序.uvproj, settings and files
target 目标 1 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: STC开源遥控器程序 +hex
  c flags: Optimize=8 SizeSpeed=1
  group 源组 1
    ./: main.c LT8910.c EEPROM.C
